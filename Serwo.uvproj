# Keil uVision project Serwo.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2129/01 NXP
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Przerwania +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Group 1
    ./: Startup.s main.c timer.c led.c timer_interrupts.c keyboard.c servo.c keyboard.h led.h servo.h timer.h timer_interrupts.h
